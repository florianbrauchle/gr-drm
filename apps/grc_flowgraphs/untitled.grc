<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Florian Brauchle</value></param>
<param><key>category</key><value>DRM</value></param>
<param><key>description</key><value>DRM-Receiver</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>DRM-Receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rxdrm_decoder_c</key>
<param><key>id</key><value>rxdrm_decoder_c_0</value></param>
<param><key>p_info</key><value>1</value></param>
</block>
<block>
<key>rxdrm_drm_equalizer_cc</key>
<param><key>id</key><value>rxdrm_drm_equalizer_cc_0</value></param>
<param><key>p_info</key><value>1</value></param>
</block>
<block>
<key>rxdrm_framer_cc</key>
<param><key>id</key><value>rxdrm_framer_cc_0</value></param>
<param><key>p_corr_limit</key><value>0.9</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>print_values</key><value>0</value></param>
</block>
<block>
<key>rxdrm_fsync_cc</key>
<param><key>id</key><value>rxdrm_fsync_cc_0</value></param>
<param><key>p_integ</key><value>1</value></param>
</block>
<block>
<key>rxdrm_md_sel_cc</key>
<param><key>id</key><value>rxdrm_md_sel_cc_0</value></param>
<param><key>p_integ</key><value>1</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>rxdrm_md_sel_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxdrm_decoder_c_0</source_block_id><sink_block_id>rxdrm_drm_equalizer_cc_0</sink_block_id><source_key>fac_out</source_key><sink_key>fac_in</sink_key></connection>
<connection><source_block_id>rxdrm_drm_equalizer_cc_0</source_block_id><sink_block_id>rxdrm_decoder_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxdrm_framer_cc_0</source_block_id><sink_block_id>rxdrm_drm_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxdrm_fsync_cc_0</source_block_id><sink_block_id>rxdrm_framer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxdrm_md_sel_cc_0</source_block_id><sink_block_id>rxdrm_fsync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
